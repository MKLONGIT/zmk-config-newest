## boards/arm/nrfNicht/board.yml
```yaml
board:
  name: nrfNicht
  full_name: nrfNicht
  vendor: mkl
  socs:
  - name: nrf52840
    variants:
    - name: zmk
```
